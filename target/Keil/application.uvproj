# Keil uVision project application.uvproj, settings and files
target Internal flash and NOR (ARM-ADS)
  device: STM32F427ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: application +hex
  c flags: Optim=4
  c define: ST STM32F469xx USE_OS_SYSTICK USE_BPP=24
  c include: ../../touchgfx/framework/include;../../gui/include;../../target/include;../../platform/os;../../generated/fonts/include;../../generated/images/include;../../generated/texts/include;../../generated/gui_generated/include;../bsp/include;../bsp/include/platform/core/arm/cortex-m/CMSIS;../bsp/include/platform/hal/mcu/stm32f4cube;../bsp/include/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver;../bsp/include/platform/hal/mcu/stm32f4cube/CMSIS;../bsp/include;../bsp/include/bsp;../bsp/source/vendor/STM32469I-Discovery;../os/FreeRTOS7.6.0/Source/include;../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F
  asm include: ../../platform/os
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ./Flash.sct
  group Startup
    ../bsp/source/platform/hal/mcu/stm32f4cube/Keil/: startup_stm32f469xx.s
    ../: main.cpp
  group TouchGFXHAL
    ../bsp/source/platform/cortex-m/: CortexMMCUInstrumentation.cpp
    ../bsp/source/platform/hal/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp
    ../bsp/source/bsp/: OTM8009TouchController.cpp Buttons.cpp KeySampler.cpp
  group HAL
    ../bsp/source/platform/hal/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../bsp/source/platform/hal/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc_ex.c
    ../bsp/source/vendor/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
    ../bsp/source/vendor/Components/ft6x06/: ft6x06.c
    ../bsp/source/vendor/Components/otm8009a/: otm8009a.c
  group OS
    ../os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group gui
    ../../gui/src/common/: frontendapplication.cpp
    ../../gui/src/model/: model.cpp
    ../../gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../../gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
    ../../gui/src/screen3_screen/: screen3presenter.cpp screen3view.cpp
    ../../gui/src/screen4_screen/: screen4presenter.cpp screen4view.cpp
    ../../gui/src/screen5_screen/: screen5presenter.cpp screen5view.cpp
  group generated
    ../../generated/images/src/: a2.cpp a3.cpp abc.cpp bitmapdatabase.cpp
    ../../generated/fonts/src/: applicationfontprovider.cpp font_lucon_ttf_23_4bpp.cpp font_verdana_115_4bpp.cpp font_verdana_20_4bpp.cpp font_verdana_23_4bpp.cpp fontgetters.cpp kerning_lucon_ttf_23_4bpp.cpp kerning_verdana_115_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_23_4bpp.cpp table_lucon_ttf_23_4bpp.cpp table_verdana_115_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_23_4bpp.cpp
    ../../generated/images/src/__designer/: blue_buttons_round_edge_small.cpp blue_buttons_round_edge_small_pressed.cpp blue_icons_down_arrow_48.cpp blue_icons_home_48.cpp blue_icons_power_48.cpp blue_icons_up_arrow_48.cpp
    ../../generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../../generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../../generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../../generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
    ../../generated/gui_generated/src/screen3_screen/: screen3viewbase.cpp
    ../../generated/gui_generated/src/screen4_screen/: screen4viewbase.cpp
    ../../generated/gui_generated/src/screen5_screen/: screen5viewbase.cpp
